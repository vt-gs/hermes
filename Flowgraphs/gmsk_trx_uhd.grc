options:
  parameters:
    author: Zach Leffke, KJ4QLP
    description: Half Duplex GMSK Ax.25 Transceiver, streaming processing
    generate_options: qt_gui
    id: gmsk_trx_uhd
    output_language: python
    title: GMSK, Ax.25, 9600, Streaming Mode
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,10,1,2
    label: TX bb_gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.75'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/2000)
  states: {}
- name: fn
  id: variable
  parameters:
    value: '"{:s}_{:s}_{:s}_{:s}k.fc32".format(sat_name, radio_id, ts_str, str(int(samp_rate/1e3)))'
  states: {}
- name: fp
  id: variable
  parameters:
    value: '"/captures/{:s}".format(fn)'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '24'
  states: {}
- name: rx_correct
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '850'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,0,1,2
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '86'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: float(250000)
  states: {}
- name: ts_str
  id: variable
  parameters:
    value: dt.strftime(dt.utcnow(), "%Y-%m-%dT%H:%M:%S.%fZ" )
  states: {}
- name: tx_correct
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,8,1,2
    orient: Qt.Horizontal
    start: '-10000'
    step: '1'
    stop: '10000'
    value: '850'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,8,1,2
    label: TX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '86'
    value: '60'
  states: {}
- name: ax25_gmsk_rx_hier_0
  id: ax25_gmsk_rx_hier
  parameters:
    lpf_cutoff: 12.5e3
    lpf_trans: 1e3
    samp_rate: '250000'
  states: {}
- name: ax25_gmsk_tx_hier_0
  id: ax25_gmsk_tx_hier
  parameters:
    bb_gain: '0.75'
    bt: '.5'
    samp_rate: '250000'
  states: {}
- name: blocks_socket_pdu_0_2
  id: blocks_socket_pdu
  parameters:
    comment: |-
      Expects KISS Frames on input
      Sends KISS Frames on output
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    host: 0.0.0.0
    mtu: '1024'
    port: '8000'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime as dt; import string
  states: {}
- name: note_0
  id: note
  parameters:
    note: Enable to Record RAW IQ
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim*interp
    comment: |-
      in0 = Pre-detection Spectrum
      in1 = Spectrum after AGC and filtering
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,4,8
    label1: pre-d
    label2: agc_filt
    legend: 'False'
    name: '"RX Spectrum"'
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-150'
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim*interp
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,8,4,4
    legend: 'False'
    name: '"TX Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-150'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim*interp
    fc: '0'
    fftsize: '2048'
    gui_hint: 4,0,2,8
    showports: 'True'
    type: complex
    update_time: '0.010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radio_id
  id: parameter
  parameters:
    type: str
    value: 30CF9D2
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    type: eng_float
    value: 401.12e6
  states: {}
- name: rx_offset
  id: parameter
  parameters:
    type: eng_float
    value: 250e3
  states: {}
- name: sat_name
  id: parameter
  parameters:
    type: str
    value: UPS1
  states: {}
- name: tx_offset
  id: parameter
  parameters:
    type: eng_float
    value: 250e3
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(rf_freq+tx_correct, tx_offset)
    clock_rate: '0.0'
    comment: |-
      UHD Underflows 'U' expected
      One per uplink packet
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: 250e3
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(rf_freq+rx_correct, rx_offset)
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pre-d
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: agc_filt
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pre-d
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: agc_filt
  states: {}

connections:
- [ax25_gmsk_rx_hier_0, '0', virtual_sink_1, '0']
- [ax25_gmsk_rx_hier_0, '1', virtual_sink_2, '0']
- [ax25_gmsk_rx_hier_0, kiss/ax25, blocks_socket_pdu_0_2, pdus]
- [ax25_gmsk_tx_hier_0, '0', rational_resampler_xxx_1, '0']
- [ax25_gmsk_tx_hier_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_socket_pdu_0_2, pdus, ax25_gmsk_tx_hier_0, kiss/ax25]
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_1_0_0, '0']
- [uhd_usrp_source_0, '0', ax25_gmsk_rx_hier_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_1_0, '1']
- [virtual_source_1_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
