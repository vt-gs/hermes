options:
  parameters:
    author: Zach Leffke, KJ4QLP
    category: '[KJ4QLP Hier Blocks]'
    description: Hierarchical AX.25 GMSK Transmitter
    generate_options: hb
    id: ax25_gmsk_tx_hier
    output_language: python
    title: 9600 Baud GMSK TX
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    comment: desired baud rate
    value: '9600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '24'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '25'
  states: {}
- name: samp_rate_var
  id: variable
  parameters:
    value: samp_rate / interp * decim
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    comment: |-
      samples per symbol
      (try to make integer)
    value: samp_rate_var/baud
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: Baseband Gain
    value: '0.75'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Baseband Gain
    const: bb_gain
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      pack bytes for 
      GMSK Mod Block
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: Block tag propagation
    propagate_tags: 'False'
    single_key: '"packet_len"'
    type: complex
  states: {}
- name: bt
  id: parameter
  parameters:
    label: BT
    value: '.5'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: bt
    comment: |-
      expects packed 
      byte stream
    samples_per_symbol: int(samps_per_symb)
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      G3RUH Polynomial
      1+x^12+x^17
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    comment: |-
      AX.25 header is not ASCII printable
      Some characters will not print properly
    label: out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    comment: |-
      Expects KISS Frames on input
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    label: kiss/ax25
    type: message
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: upsample to 250k for UHD
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '250000'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    comment: |-
      Computes FCS, append
      Bit Stuff Frame
      Append/Prepend Flags
    postamble_bytes: '64'
    preamble_bytes: '64'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    comment: |-
      Discard KISS FEND bytes
      Escapes Bytes as necessary
      Removes KISS CMD Byte
    control_byte: 'True'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters:
    comment: |-
      NRZI Differential
      Line Encoding
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_0_2_0_1
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_scrambler_bb_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', satellites_kiss_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_tag_gate_0, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_1, pdus]
- [rational_resampler_xxx_0, '0', pad_sink_1, '0']
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [satellites_kiss_to_pdu_0, out, pad_sink_0, in]
- [satellites_kiss_to_pdu_0, out, satellites_hdlc_framer_0, in]
- [satellites_nrzi_encode_0, '0', blocks_pack_k_bits_bb_0, '0']
- [virtual_source_0_2_0_1, '0', digital_gmsk_mod_0, '0']

metadata:
  file_format: 1
