options:
  parameters:
    author: Zach Leffke, KJ4QLP
    category: '[KJ4QLP Hier Blocks]'
    description: Hierarchical GMSK AX.25 Receiver
    generate_options: hb
    id: ax25_gmsk_rx_hier
    output_language: python
    title: 9600 Baud GMSK RX
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/2000)
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '24'
  states: {}
- name: samps_per_symb
  id: variable
  parameters:
    value: (samp_rate/decim*interp)/baud
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: automatic gain control
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      FSK/GMSK
      demodulator
    gain: (samp_rate/decim*interp)/(2*math.pi*fsk_dev/8.0)
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: soft bits to hard bits
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Timing Recovery
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.25'
    omega: samps_per_symb*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      G3RUH Polynomial
      1+x^12+x^17
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: narrow signal filter
    cutoff_freq: lpf_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim *interp
    type: fir_filter_ccf
    width: lpf_trans
    win: firdes.WIN_HAMMING
  states: {}
- name: lpf_cutoff
  id: parameter
  parameters:
    label: LPF Cut Off
    type: eng_float
    value: 12.5e3
  states: {}
- name: lpf_trans
  id: parameter
  parameters:
    label: LPF Trans
    type: eng_float
    value: 1e3
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pre-d, 48k
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: agc/filt, 48k
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    comment: |-
      Output is KISS Frame
      <FEND><CMD><DATA><FEND>
      DATA = AX.25 Frame
    label: kiss/ax25
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: reduce to 48k sample rate
    decim: decim
    fbw: ''
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '250000'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    comment: |-
      Searches for flags to detect Frame
      'unstuffs' tx bit stuffing
      checks FCS for bit errors
    max_length: '300'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters:
    comment: |-
      NRZI Differential
      Line Decoding
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters:
    comment: |-
      Wraps AX.25 Frame in KISS protocol
      <FEND><CMD><DATA><FEND>
      Escapes DATA bytes as needed
    control_byte: 'True'
    include_timestamp: 'False'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: soft_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: soft_bits
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_1, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_descrambler_bb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0, '0']
- [digital_descrambler_bb_0, '0', satellites_nrzi_decode_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_1, '0']
- [low_pass_filter_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_0, '0']
- [satellites_hdlc_deframer_0, out, satellites_pdu_to_kiss_0, in]
- [satellites_nrzi_decode_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_pdu_to_kiss_0, out, pad_sink_0_0_0, in]
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
